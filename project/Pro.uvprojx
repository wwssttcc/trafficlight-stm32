# Keil uVision project Pro.uvprojx, settings and files
target STM32F407 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro +hex
  AfterMake: E:\tools\keil\ARM\ARMCC\bin\fromelf.exe --bin -o  .\Debug\TrafficLight.bin .\Debug\Pro.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4
  c include: ..\App;..\BSP;..\Module;..\CMSIS\Core;..\CMSIS\Driver;..\UCOS\Source;..\UCOS\Port;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Utilities\Third_Party\lwip_v1.3.2\src\api;..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\netif\ppp;..\CMSIS\STM32F4x7_ETH_Driver\inc;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\arch;..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: Main.c task_trafficlight.c trafficlight.c rsu_parse.c sys.c iap.c
  group BSP
    ../BSP/: LED.C Bsp_Global.c NVIC.C stm32f4x7_eth_bsp.c netconf.c stm32f4xx_it.c SCI.c drv_trafficlight.c stmflash.c ring_buffer.c TCP_SERVER.C IWDG.C
  group Module
    ../Module/: M_CMSIS_P.h M_Delay_P.c M_Delay_P.h M_Global.c M_Global.h M_Type_P.h
  group CMSIS/Driver
    ../CMSIS/Driver/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group CMSIS/Core
    ../CMSIS/Core/: startup_stm32f4xx.s system_stm32f4xx.c arm_cortexM4lf_math.lib
  group UCOS/Port
    ../UCOS/Port/: app_cfg.h os_cfg.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c ucosii_inc.h
  group UCOS/Source
    ../UCOS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group LWIP
    ../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4x7_ETH_Driver
    ../CMSIS/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
